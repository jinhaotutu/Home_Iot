# Keil uVision project ucos_stm32f4.uvprojx, settings and files
target ucos_stm32f4 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucos_stm32f4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\fwlib\inc;..\misis;..\task;..\ucos_II\Ports;..\ucos_II\Source;..\user;..\dev\onenet;..\dev\wifi;..\dev\temp;..\dev\oled;..\dev\rtc;..\dev\infrared;..\dev\ov7670;..\dev\rgb2bmp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c stm32f4xx_it.c sys_cfg.c sys_delay.c
  group ucos_task
    ../task/: task_start.c task_led.c task_wifi.c task_temp.c
  group ucos_port
    ../ucos_II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucos_core
    ../ucos_II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dcmi.c
  group misis
    ../misis/: system_stm32f4xx.c
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group wifi
    ../dev/wifi/: net_device.c net_io.c
  group onenet
    ../dev/onenet/: dStream.c EdpKit.c fault.c onenet.c
  group temp
    ../dev/temp/: SI7021.c
  group oled
    ../dev/oled/: oled.c
  group ov7670
    ../dev/ov7670/: dcmi.c ov7670.c ov7670test.c sccb.c
  group rgb2bmp
    ../dev/rgb2bmp/: rgb2bmp.c
  group infrared
    ../dev/infrared/: infrared.c
